# Keil uVision project app.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x1800) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: FreeRTOS +hex
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ARMCM0,HOST_SEND_HEX=0,HOST_SEND_ASC=1,HOST_SEND=HOST_SEND_ASC
  c include: ..\..\Device\Include;..\..\Drivers\Include;..\FreeRtosSrc\include;..\FreeRtosSrc\Common\include;..\main;..\mcu;..\bsp;..\sensirion
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1800
  group main
    ../main/: main.c task_main.c proc.c peri.c disp.c mon.c sensirion.c
    ./: 참고.txt
  group mcu
    ../mcu/: A31G12x_I2Cn_sg.c uart_a31g12x.c uart1n_a31g12x.c i2c_a31g12x.c
  group Startup
    ../../Device/Source/ARM/: startup_A31G12x.s
  group Option
    ../Option/KEIL/: option_A31G12x.s
  group Device
    ../../Device/Source/: system_A31G12x.c
  group Drivers
    ../../Drivers/Source/: A31G12x_ADC.c A31G12x_CRC.c A31G12x_FMC.c A31G12x_INTC.c A31G12x_LCD.c A31G12x_PCU.c A31G12x_PWR.c A31G12x_SCUCC.c A31G12x_SCUCG.c A31G12x_SCULV.c A31G12x_TIMER1n.c A31G12x_TIMER2n.c A31G12x_TIMER3n.c A31G12x_UARTn.c A31G12x_USART1n.c A31G12x_WDT.c A31G12x_WT.c debug_frmwrk.c slib.c
  group FreeRTOS files
    ../FreeRtosSrc/: tasks.c list.c queue.c
    ../FreeRtosSrc/portable/RVDS/ARM_CM0/: port.c
    ../FreeRtosSrc/portable/MemMang/: heap_2.c
  group bsp
    ../bsp/: ESP32.c ir_nec.c ir_nec_hal.c mc2012_hal.c mc2102.c modbus.c modbus_hal.c
  group sensirion
    ../sensirion/: sensirion_common.c sensirion_i2c_sg.c sgp30.c sht3x.c sps30.c
software components: CMSIS:CORE 5.1.1
